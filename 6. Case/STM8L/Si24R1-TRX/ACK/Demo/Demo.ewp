# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.srec
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: APP; BSP; DRIVER\MCU\STM8L10x_StdPeriph_Driver\inc; DRIVER\RF; UTILITY
  OBJCOPY.OOCOutputFile: Demo.hex
  group APP
    APP/: app.c main.c stm8l10x_it.c
  group BSP
    BSP/: bsp.c
  group DRIVER/MCU
    DRIVER/MCU/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_beep.c stm8l10x_clk.c stm8l10x_comp.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_i2c.c stm8l10x_irtim.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_rst.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c stm8l10x_wfe.c
  group DRIVER/RF
    DRIVER/RF/: nRF24L01P.c
  group UTILITY
    UTILITY/: RingBuffer.c

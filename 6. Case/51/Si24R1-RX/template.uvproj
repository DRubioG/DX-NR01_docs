# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\Si24R1;.\Public
  group User
    ./User/: main.c
  group App
    ./App/Si24R1/: Si24R1.c
  group Public
    ./Public/: public.c uart.c spi.c
